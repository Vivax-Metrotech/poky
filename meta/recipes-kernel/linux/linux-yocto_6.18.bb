KBRANCH ?= "v6.18/standard/base"

require recipes-kernel/linux/linux-yocto.inc

# CVE exclusions
include recipes-kernel/linux/cve-exclusion.inc

# board specific branches
KBRANCH:qemuarm  ?= "v6.18/standard/arm-versatile-926ejs"
KBRANCH:qemuarm64 ?= "v6.18/standard/base"
KBRANCH:qemuloongarch64  ?= "v6.18/standard/base"
KBRANCH:qemumips ?= "v6.18/standard/mti-malta"
KBRANCH:qemuppc  ?= "v6.18/standard/qemuppc"
KBRANCH:qemuriscv64  ?= "v6.18/standard/base"
KBRANCH:qemuriscv32  ?= "v6.18/standard/base"
KBRANCH:qemux86  ?= "v6.18/standard/base"
KBRANCH:qemux86.104 ?= "v6.18/standard/base"

SRCREV_machine:qemuarm ?= "a05c451ede0dd80b1cc2362b47f36f3c137cbd1e"
SRCREV_machine:qemuarm64 ?= "a05c451ede0dd80b1cc2362b47f36f3c137cbd1e"
SRCREV_machine:qemuloongarch64 ?= "a05c451ede0dd80b1cc2362b47f36f3c137cbd1e"
SRCREV_machine:qemumips ?= "a05c451ede0dd80b1cc2362b47f36f3c137cbd1e"
SRCREV_machine:qemuppc ?= "a05c451ede0dd80b1cc2362b47f36f3c137cbd1e"
SRCREV_machine:qemuriscv64 ?= "a05c451ede0dd80b1cc2362b47f36f3c137cbd1e"
SRCREV_machine:qemuriscv32 ?= "a05c451ede0dd80b1cc2362b47f36f3c137cbd1e"
SRCREV_machine:qemux86 ?= "a05c451ede0dd80b1cc2362b47f36f3c137cbd1e"
SRCREV_machine:qemux86-64 ?= "a05c451ede0dd80b1cc2362b47f36f3c137cbd1e"
SRCREV_machine ?= "a05c451ede0dd80b1cc2362b47f36f3c137cbd1e"
SRCREV_meta ?= "2f71b0a288c307062fc60948ac793d8d51c685e2"

BBCLASSEXTEND = "devupstream:target"
SRCREV_machine:class-devupstream ?= "a05c451ede0dd80b1cc2362b47f36f3c137cbd1e"
PN:class-devupstream = "linux-yocto-upstream"
KBRANCH:class-devupstream = "v6.18/base"

SRC_URI = "git://git.yoctoproject.org/linux-yocto.git;name=machine;branch=${KBRANCH};protocol=https \
           git://git.yoctoproject.org/yocto-kernel-cache;type=kmeta;name=meta;branch=yocto-6.18;destsuffix=${KMETA};protocol=https \
           file://0002-tcp-add-preempt-disable-enable-nested-in-reqsk_queue_hash_req.patch \
           file://0003-bpf-fix-same-register-dst-src-oob-read-and-pointer-leak-in-sock_ops.patch \
           file://0004-bpf-fix-use-after-free-in-offloaded-map-prog-info-fill.patch \
           file://0005-nsfs-tighten-permission-checks-for-handle-opening.patch \
           file://0006-net-pull-headers-in-qdisc-pkt-len-init.patch"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
LINUX_VERSION ?= "6.18.39"

# These are already fixed or backported in the current 6.18.39 stable series.
CVE_STATUS[CVE-2023-52904] = "fixed-version: Fixed from version 5.15.168"
CVE_STATUS[CVE-2025-71289] = "cpe-stable-backport: Backported in 6.18.34"
CVE_STATUS[CVE-2026-23327] = "cpe-stable-backport: Backported in 6.18.34"
CVE_STATUS[CVE-2026-23371] = "cpe-stable-backport: Backported in 6.18.34"
CVE_STATUS[CVE-2026-23442] = "cpe-stable-backport: Backported in 6.18.25"
CVE_STATUS[CVE-2026-31420] = "cpe-stable-backport: Backported in 6.18.34"
CVE_STATUS[CVE-2026-31560] = "cpe-stable-backport: Backported in 6.18.34"
CVE_STATUS[CVE-2026-31589] = "cpe-stable-backport: Backported in 6.18.27"
CVE_STATUS[CVE-2026-31709] = "cpe-stable-backport: Backported in 6.18.35"
CVE_STATUS[CVE-2026-43131] = "fixed-version: only affects 6.19 onwards"
CVE_STATUS[CVE-2026-45945] = "cpe-stable-backport: Backported in 6.18.39"
CVE_STATUS[CVE-2026-46054] = "cpe-stable-backport: Backported in 6.18.38"
CVE_STATUS[CVE-2026-46092] = "cpe-stable-backport: Backported in 6.18.27"
CVE_STATUS[CVE-2026-46203] = "cpe-stable-backport: Backported in 6.18.36"
CVE_STATUS[CVE-2026-46252] = "cpe-stable-backport: Backported in 6.18.37"
CVE_STATUS[CVE-2026-53027] = "cpe-stable-backport: Backported in 6.18.39"
CVE_STATUS[CVE-2026-53078] = "backported-patch: fixed by 0003-bpf-fix-same-register-dst-src-oob-read-and-pointer-leak-in-sock_ops.patch"
CVE_STATUS[CVE-2026-53089] = "backported-patch: fixed by 0004-bpf-fix-use-after-free-in-offloaded-map-prog-info-fill.patch"
CVE_STATUS[CVE-2026-53091] = "backported-patch: fixed by 0006-net-pull-headers-in-qdisc-pkt-len-init.patch"
CVE_STATUS[CVE-2026-53232] = "cpe-stable-backport: Backported in 6.18.36"
CVE_STATUS[CVE-2026-53260] = "backported-patch: fixed by 0002-tcp-add-preempt-disable-enable-nested-in-reqsk_queue_hash_req.patch"
CVE_STATUS[CVE-2018-10902] = "not-applicable-config: CONFIG_SND_RAWMIDI is not enabled in this kernel build"
CVE_STATUS[CVE-2020-1749] = "not-applicable-config: CONFIG_IP_VXLAN and CONFIG_GENEVE are not enabled in this kernel build"
CVE_STATUS[CVE-2020-25672] = "not-applicable-config: CONFIG_NFC is not enabled in this kernel build"
CVE_STATUS[CVE-2020-27815] = "not-applicable-config: CONFIG_JFS_FS is not enabled in this kernel build"
CVE_STATUS[CVE-2021-20194] = "not-applicable-config: requires CONFIG_HARDENED_USERCOPY to be disabled, but it is enabled in this kernel build"
CVE_STATUS[CVE-2022-0400] = "not-applicable-config: CONFIG_SMC is not enabled in this kernel build"
CVE_STATUS[CVE-2023-39179] = "not-applicable-config: CONFIG_KSMBD is not enabled in this kernel build"
CVE_STATUS[CVE-2026-23459] = "not-applicable-config: CONFIG_IP_VXLAN and CONFIG_GENEVE are not enabled in this kernel build"
CVE_STATUS[CVE-2026-31501] = "not-applicable-config: CONFIG_TI_ICSSG_PRUETH is not enabled in this kernel build"
CVE_STATUS[CVE-2026-31771] = "not-applicable-config: CONFIG_BT is not enabled in this kernel build"
CVE_STATUS[CVE-2026-43414] = "not-applicable-config: CONFIG_SCSI_QLA_FC is not enabled in this kernel build"
CVE_STATUS[CVE-2026-46210] = "not-applicable-config: CONFIG_VIDEO_QCOM_IRIS is not enabled in this kernel build"
CVE_STATUS[CVE-2026-46311] = "not-applicable-config: CONFIG_DRM_AMDGPU is not enabled in this kernel build"
CVE_STATUS[CVE-2026-46330] = "not-applicable-config: CONFIG_SMC is not enabled in this kernel build"
CVE_STATUS[CVE-2026-52956] = "not-applicable-config: CONFIG_CEPH_LIB is not enabled in this kernel build"
CVE_STATUS[CVE-2026-52960] = "not-applicable-config: CONFIG_CEPH_LIB is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53009] = "not-applicable-config: CONFIG_ICE is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53024] = "not-applicable-config: CONFIG_GREYBUS is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53025] = "not-applicable-config: CONFIG_GREYBUS is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53178] = "not-applicable-config: CONFIG_RTL8723BS is not enabled in this kernel build"
CVE_STATUS[CVE-2017-1000255] = "not-applicable-config: this build targets ARM and does not enable PowerPC support"
CVE_STATUS[CVE-2019-3016] = "not-applicable-config: CONFIG_KVM is not enabled in this kernel build"
CVE_STATUS[CVE-2019-3887] = "not-applicable-config: CONFIG_KVM is not enabled in this kernel build"
CVE_STATUS[CVE-2020-16119] = "not-applicable-config: CONFIG_DCCP is not enabled in this kernel build"
CVE_STATUS[CVE-2021-3564] = "not-applicable-config: CONFIG_BT is not enabled in this kernel build"
CVE_STATUS[CVE-2022-1247] = "not-applicable-config: CONFIG_ROSE is not enabled in this kernel build"
CVE_STATUS[CVE-2022-2308] = "not-applicable-config: CONFIG_VDPA and CONFIG_VDUSE are not enabled in this kernel build"
CVE_STATUS[CVE-2022-3619] = "not-applicable-config: CONFIG_BT is not enabled in this kernel build"
CVE_STATUS[CVE-2022-4382] = "not-applicable-config: CONFIG_GADGETFS is not enabled in this kernel build"
CVE_STATUS[CVE-2023-1074] = "not-applicable-config: CONFIG_IP_SCTP is not enabled in this kernel build"
CVE_STATUS[CVE-2023-39176] = "not-applicable-config: CONFIG_SMB_SERVER is not enabled in this kernel build"
CVE_STATUS[CVE-2023-39180] = "not-applicable-config: CONFIG_SMB_SERVER is not enabled in this kernel build"
CVE_STATUS[CVE-2023-7042] = "not-applicable-config: CONFIG_ATH10K is not enabled in this kernel build"
CVE_STATUS[CVE-2025-71074] = "not-applicable-config: CONFIG_USB_FUNCTIONFS is not enabled in this kernel build"
CVE_STATUS[CVE-2025-71306] = "not-applicable-config: CONFIG_IMA and CONFIG_SECURITYFS are not enabled in this kernel build"
CVE_STATUS[CVE-2025-71308] = "not-applicable-config: CONFIG_AMD_XDNA is not enabled in this kernel build"
CVE_STATUS[CVE-2025-71313] = "not-applicable-config: CONFIG_PCI_ENDPOINT is not enabled in this kernel build"
CVE_STATUS[CVE-2026-23328] = "not-applicable-config: CONFIG_AMD_XDNA is not enabled in this kernel build"
CVE_STATUS[CVE-2026-23377] = "not-applicable-config: CONFIG_ICE is not enabled in this kernel build"
CVE_STATUS[CVE-2026-31777] = "not-applicable-config: CONFIG_SND_CTXFI is not enabled in this kernel build"
CVE_STATUS[CVE-2026-43022] = "not-applicable-config: CONFIG_BT is not enabled in this kernel build"
CVE_STATUS[CVE-2026-43042] = "not-applicable-config: CONFIG_MPLS is not enabled in this kernel build"
CVE_STATUS[CVE-2026-43045] = "not-applicable-config: CONFIG_MSHV and CONFIG_HYPERV are not enabled in this kernel build"
CVE_STATUS[CVE-2026-43095] = "not-applicable-config: CONFIG_QCOM_Q6ASM is not enabled in this kernel build"
CVE_STATUS[CVE-2026-43191] = "not-applicable-config: CONFIG_DRM_AMDGPU is not enabled in this kernel build"
CVE_STATUS[CVE-2026-43204] = "not-applicable-config: CONFIG_QCOM_Q6ASM is not enabled in this kernel build"
CVE_STATUS[CVE-2026-43443] = "not-applicable-config: CONFIG_SND_SOC_AMD_ACP is not enabled in this kernel build"
CVE_STATUS[CVE-2026-45991] = "not-applicable-config: CONFIG_UDF_FS is not enabled in this kernel build"
CVE_STATUS[CVE-2026-46130] = "not-applicable-config: CONFIG_DM_VERITY_FEC is not enabled in this kernel build"
CVE_STATUS[CVE-2026-46245] = "not-applicable-config: CONFIG_DRM_AMDGPU is not enabled in this kernel build"
CVE_STATUS[CVE-2026-52988] = "not-applicable-config: CONFIG_NFT_COUNTER is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53007] = "not-applicable-config: CONFIG_ICE is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53008] = "not-applicable-config: CONFIG_ICE is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53102] = "not-applicable-config: CONFIG_MT76 is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53222] = "not-applicable-config: CONFIG_OCP_FS is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53285] = "not-applicable-config: CONFIG_DRM_AMDGPU is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53308] = "not-applicable-config: CONFIG_MAX77705 is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53313] = "not-applicable-config: CONFIG_DRM_AMDGPU is not enabled in this kernel build"
CVE_STATUS[CVE-2020-8834] = "not-applicable-config: this build targets ARM and does not enable PowerPC KVM support"
CVE_STATUS[CVE-2021-4218] = "not-applicable-config: CONFIG_SVC_RDMA is not enabled in this kernel build"
CVE_STATUS[CVE-2022-2663] = "not-applicable-config: CONFIG_NETFILTER_XT_MATCH_IRC is not enabled in this kernel build"
CVE_STATUS[CVE-2022-3621] = "not-applicable-config: CONFIG_NILFS2_FS is not enabled in this kernel build"
CVE_STATUS[CVE-2022-3633] = "not-applicable-config: CONFIG_CAN_J1939 is not enabled in this kernel build"
CVE_STATUS[CVE-2022-3636] = "not-applicable-config: CONFIG_NET_MEDIATEK_HNAT is not enabled in this kernel build"
CVE_STATUS[CVE-2022-3646] = "not-applicable-config: CONFIG_NILFS2_FS is not enabled in this kernel build"
CVE_STATUS[CVE-2022-36402] = "not-applicable-config: CONFIG_DRM_VMWGFX is not enabled in this kernel build"
CVE_STATUS[CVE-2022-38096] = "not-applicable-config: CONFIG_DRM_VMWGFX is not enabled in this kernel build"
CVE_STATUS[CVE-2022-42895] = "not-applicable-config: CONFIG_BT is not enabled in this kernel build"
CVE_STATUS[CVE-2023-1075] = "not-applicable-config: CONFIG_TLS is not enabled in this kernel build"
CVE_STATUS[CVE-2023-2898] = "not-applicable-config: CONFIG_F2FS_FS is not enabled in this kernel build"
CVE_STATUS[CVE-2023-3397] = "not-applicable-config: CONFIG_JFS_FS is not enabled in this kernel build"
CVE_STATUS[CVE-2023-3640] = "not-applicable-config: this build targets ARM and does not enable x86 cpu_entry_area handling"
CVE_STATUS[CVE-2023-4155] = "not-applicable-config: CONFIG_KVM and CONFIG_AMD_MEM_ENCRYPT are not enabled in this kernel build"
CVE_STATUS[CVE-2023-6238] = "not-applicable-config: CONFIG_NVME_CORE is not enabled in this kernel build"
CVE_STATUS[CVE-2023-6535] = "not-applicable-config: CONFIG_NVME_TCP is not enabled in this kernel build"
CVE_STATUS[CVE-2023-6679] = "not-applicable-config: CONFIG_DPLL is not enabled in this kernel build"
CVE_STATUS[CVE-2026-43310] = "not-applicable-config: CONFIG_VIDEO_VERISILICON and CONFIG_VIDEO_HANTRO are not enabled in this kernel build"
CVE_STATUS[CVE-2026-43311] = "not-applicable-config: CONFIG_ARCH_TEGRA is not enabled in this kernel build"
CVE_STATUS[CVE-2026-43344] = "not-applicable-config: this build targets ARM and does not enable x86 Intel uncore perf support"
CVE_STATUS[CVE-2026-43391] = "backported-patch: fixed by 0005-nsfs-tighten-permission-checks-for-handle-opening.patch"
CVE_STATUS[CVE-2026-45961] = "not-applicable-config: CONFIG_GFS2_FS is not enabled in this kernel build"
CVE_STATUS[CVE-2026-45963] = "not-applicable-config: CONFIG_SND_SOC_NAU8821 is not enabled in this kernel build"
CVE_STATUS[CVE-2026-46032] = "not-applicable-config: CONFIG_KVM is not enabled in this kernel build"
CVE_STATUS[CVE-2026-46298] = "not-applicable-config: this build targets ARM and does not enable PowerPC pseries support"
CVE_STATUS[CVE-2026-46302] = "not-applicable-config: CONFIG_SELINUX is not enabled in this kernel build"
CVE_STATUS[CVE-2026-52949] = "not-applicable-config: CONFIG_TTM and CONFIG_DRM_TTM_HELPER are not enabled in this kernel build"
CVE_STATUS[CVE-2026-52965] = "not-applicable-config: CONFIG_TTM and CONFIG_DRM_TTM_HELPER are not enabled in this kernel build"
CVE_STATUS[CVE-2026-53113] = "not-applicable-config: CONFIG_ATH11K is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53124] = "not-applicable-config: CONFIG_UBLK is not enabled in this kernel build"
CVE_STATUS[CVE-2026-53108] = "not-applicable-config: this build targets ARM and does not enable PowerPC 64s MMU support"
CVE_STATUS[CVE-2026-53292] = "not-applicable-config: CONFIG_PHONET is not enabled in this kernel build"

PV = "${LINUX_VERSION}+git"

KMETA = "kernel-meta"
KCONF_BSP_AUDIT_LEVEL = "1"

KERNEL_DEVICETREE:qemuarmv5 = "arm/versatile-pb.dtb"

COMPATIBLE_MACHINE = "^(qemuarm|qemuarmv5|qemuarm64|qemux86|qemuppc|qemuppc64|qemumips|qemux86-64|qemuriscv64|qemuriscv32|qemuloongarch64)$"

# Functionality flags
KERNEL_EXTRA_FEATURES ?= "features/netfilter/netfilter.scc"
KERNEL_FEATURES:append = " ${KERNEL_EXTRA_FEATURES}"
KERNEL_FEATURES:append:qemuall = " cfg/virtio.scc features/drm-bochs/drm-bochs.scc cfg/net/mdio.scc"
KERNEL_FEATURES:append:qemux86 = " cfg/sound.scc cfg/paravirt_kvm.scc"
KERNEL_FEATURES:append:qemux86-64 = " cfg/sound.scc cfg/paravirt_kvm.scc"
KERNEL_FEATURES:append = " ${@bb.utils.contains('TUNE_FEATURES', 'mx32', ' cfg/x32.scc', '', d)}"
KERNEL_FEATURES:append = " ${@bb.utils.contains('DISTRO_FEATURES', 'ptest', ' features/scsi/scsi-debug.scc features/nf_tables/nft_test.scc', '', d)}"
KERNEL_FEATURES:append = " ${@bb.utils.contains('DISTRO_FEATURES', 'ptest', ' features/gpio/mockup.scc features/gpio/sim.scc', '', d)}"
KERNEL_FEATURES:append = " ${@bb.utils.contains('KERNEL_DEBUG', 'True', ' features/reproducibility/reproducibility.scc features/debug/debug-btf.scc', '', d)}"
KERNEL_FEATURES:append = " ${@bb.utils.contains('DISTRO_FEATURES', 'ptest', ' features/net/team/team.scc', '', d)}"
KERNEL_FEATURES:append = " ${@bb.utils.contains('DISTRO_FEATURES', 'ptest', ' cgl/cfg/net/l2tp.scc', '', d)}"
KERNEL_FEATURES:append:powerpc = " arch/powerpc/powerpc-debug.scc"
KERNEL_FEATURES:append:powerpc64 = " arch/powerpc/powerpc-debug.scc"
KERNEL_FEATURES:append:powerpc64le = " arch/powerpc/powerpc-debug.scc"

INSANE_SKIP:kernel-vmlinux:qemuppc64 = "textrel"
