require ${THISDIR}/rauc-stdio.inc
